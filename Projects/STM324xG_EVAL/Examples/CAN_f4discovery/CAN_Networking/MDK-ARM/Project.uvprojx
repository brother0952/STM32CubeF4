# Keil uVision project Project.uvprojx, settings and files
target STM32_f4_discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c
  group Example/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_spi.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
